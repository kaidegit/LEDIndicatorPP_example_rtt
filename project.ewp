# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; STM32H750xx; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\libc\posix\io\poll; ..\..\..\libcpu\arm\common; board\port\lcd; ..\libraries\HAL_Drivers\drivers; ..\..\..\components\dfs\dfs_v1\include; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\drivers\spi\sfud\inc; .; ..\..\..\libcpu\arm\cortex-m7; ..\libraries\HAL_Drivers; ..\libraries\HAL_Drivers\drivers\config; ..\..\..\components\finsh; applications; board\port; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\drivers\phy; board; board\CubeMX_Config\Inc; ..\..\..\include; ..\..\..\components\libc\posix\ipc; ..\..\..\components\drivers\smp_call; ..\..\..\components\drivers\include; ..\..\..\components\drivers\spi; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\dfs\dfs_v1\filesystems\devfs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial_v2.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_qspi.c drv_spi.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    board/port/lcd/: drv_lcd_spi.c drv_lcd_spi_ext.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c msh_file.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
